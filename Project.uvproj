# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源文件
    ./: main.c Delay.c LED.c Timer0.c
  group 头文件
    ./: Delay.h LED.h Timer0.h
